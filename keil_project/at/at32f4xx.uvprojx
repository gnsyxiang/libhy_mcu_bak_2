# Keil uVision project at32f4xx.uvprojx, settings and files
target at32f4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libhy_mcu (library)
  AfterMake: \\192.168.3.58\uos-samba\opt\data\office\xia\libhy_mcu\keil_project\at\install_libhy_mcu.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,LIBRARY_VERSION, AT_START_F407_V1_0
  c include: ..\..\src\at\at32f4xx\AT32F4xx_StdPeriph_Lib_V1.3.2\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\src\at\at32f4xx\AT32F4xx_StdPeriph_Lib_V1.3.2\Libraries\CMSIS\CM4\CoreSupport;..\..\src\at\at32f4xx\AT32F4xx_StdPeriph_Lib_V1.3.2\Libraries\CMSIS\CM4\DeviceSupport
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group CMSIS
    ../../src/at/at32f4xx/AT32F4xx_StdPeriph_Lib_V1.3.2/Libraries/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c
    ../../src/at/at32f4xx/AT32F4xx_StdPeriph_Lib_V1.3.2/Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group driver
    ../../src/at/at32f4xx/AT32F4xx_StdPeriph_Lib_V1.3.2/Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
